# Repository joe-skb7/max7325-pcb

File README:

MAX7325 Demo Board (I2C I/O Expander)

## KiCad design max7325_dev.kicad_pcb

File README.md:

# MAX7325 Demo Board (I2C I/O Expander)

This project contains schematic and PCB for MAX7325 Demo Board. The idea behind
this project is to test MAX732x driver in Linux kernel (e.g. using BeagleBone
Black board). This is basically just a breakout board, no automation
capabilities or any fancy features added.

KiCad v5.0.1 was used for this project.

## Photo

3D Model, Front View:

3D Model, Bottom View:

Schematic:

## Authors

**Sam Protsenko**

## License

This project is licensed under the GPLv3.

Parts:
C1: 0.1uF; C_1206_3216Metric
D0, D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15: LED; LED_D5.0mm
J1: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
JP0, JP1, JP2, JP3, JP4, JP5, JP6, JP7: Jumper_NC_Dual; PinHeader_1x03_P2.54mm_Vertical
MK1, MK2, MK3, MK4: Mounting_Hole_PAD; MountingHole_3.2mm_M3_Pad
R0, R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15: 220R; R_1206_3216Metric
R16, R17, R100, R101, R102, R103, R104, R105, R106, R107: 10k; R_1206_3216Metric
R18, R19, R20, R21: 0R; R_1206_3216Metric
SW0, SW1, SW2, SW3, SW4, SW5, SW6, SW7: SW_Push; SW_PUSH_6mm
U1: MAX7325AEG+; QSOP-24_3.9x8.7mm_P0.635mm

Connections:
+3V3: C1.1, D0.2 (A), D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), J1.1, R16.1, R17.1, R18.1, R19.1, R100.1, R101.1, R102.1, R103.1, R104.1, R105.1, R106.1, R107.1, U1.24 (V+)
/INT: J1.4, R17.2, U1.1 (~INT)
/O8: R8.1, U1.13 (O8)
/O9: R9.1, U1.14 (O9)
/O10: R10.1, U1.15 (O10)
/O11: R11.1, U1.16 (O11)
/O12: R12.1, U1.17 (O12)
/O13: R13.1, U1.18 (O13)
/O14: R14.1, U1.19 (O14)
/O15: R15.1, U1.20 (O15)
/P0: JP0.2, U1.4 (P0)
/P1: JP1.2, U1.5 (P1)
/P2: JP2.2, U1.6 (P2)
/P3: JP3.2, U1.7 (P3)
/P4: JP4.2, U1.8 (P4)
/P5: JP5.2, U1.9 (P5)
/P6: JP6.2, U1.10 (P6)
/P7: JP7.2, U1.11 (P7)
/RST: J1.5, R16.2, U1.2 (~RST)
/SCL: J1.2, U1.22 (SCL)
/SDA: J1.3, U1.23 (SDA)
GND: C1.2, J1.6, MK1.1, MK2.1, MK3.1, MK4.1, R20.2, R21.2, SW0.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, U1.12 (GND)
unnamed: D0.1 (K), R0.2
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: D3.1 (K), R3.2
unnamed: D4.1 (K), R4.2
unnamed: D5.1 (K), R5.2
unnamed: D6.1 (K), R6.2
unnamed: D7.1 (K), R7.2
unnamed: D8.1 (K), R8.2
unnamed: D9.1 (K), R9.2
unnamed: D10.1 (K), R10.2
unnamed: D11.1 (K), R11.2
unnamed: D12.1 (K), R12.2
unnamed: D13.1 (K), R13.2
unnamed: D14.1 (K), R14.2
unnamed: D15.1 (K), R15.2
unnamed: JP0.1, R0.1
unnamed: JP0.3, R100.2, SW0.1
unnamed: JP1.1, R1.1
unnamed: JP1.3, R101.2, SW1.1
unnamed: JP2.1, R2.1
unnamed: JP2.3, R102.2, SW2.1
unnamed: JP3.1, R3.1
unnamed: JP3.3, R103.2, SW3.1
unnamed: JP4.1, R4.1
unnamed: JP4.3, R104.2, SW4.1
unnamed: JP5.1, R5.1
unnamed: JP5.3, R105.2, SW5.1
unnamed: JP6.1, R6.1
unnamed: JP6.3, R106.2, SW6.1
unnamed: JP7.1, R7.1
unnamed: JP7.3, R107.2, SW7.1
unnamed: R18.2, R20.1, U1.21 (AD0)
unnamed: R19.2, R21.1, U1.3 (AD2)

Notes on the sheet:
R100-R107
I2C addresses: - 0x68: P0-P7 - 0x58: O8-O15

Board: 2 copper layers, 100.3 x 80.0 mm, 69 parts (32 on the bottom side), 56 nets.

## Commit log

2018-04-06 Add README file
2018-04-06 Add newly created KiCad files
2018-04-06 schematic: Add title block content
2018-04-06 .gitignore: Add *.bak files
2018-04-06 Add cache lib
    -cache.lib: a local copy of all the symbols used in the corresponding
    schematic, so that when the folder containing a KiCad project is copied
    to a different PC, the schematic can still be opened and printed and
    will still look the same as the original draughtsperson intended - even
    if that other PC does not have those symbols in its main libraries
    (or has symbols that coincidentally have the same name but are
2018-04-06 pcb: Add title block content
2018-04-06 .gitignore: Add *.kicad_pcb-bak
2018-04-06 README: Convert to markdown format and improve
    Preparation for GitHub hosting.
2018-04-06 project: Add Maxim library for MAX7325 chip
    It was done in schematic editor (Eeschema):
    Preferences -> Component Libraries -> Add (component library files)
    -> /usr/share/kicad/library/maxim.lib
2018-04-06 schematic: Draw first part of a scheme
2018-04-06 gitignore: Add *.net
2018-04-07 schematic: Finish the schematic
2018-04-07 pcb: Place components on PCB
    1. Export NET file from schematic editor
    2. Import NET file in PCB editor
2018-04-07 schematic: Finalaze schematic changes
2018-04-07 pcb: Finish PCB layout
2018-04-08 pcb: Add silk text for header pins
2019-01-03 Migrate to KiCad 5.0
2020-02-19 doc: Add screenshots of PCB and schematic
2024-08-24 README: Mention KiCad version used for this project
2025-08-15 Create LICENSE
